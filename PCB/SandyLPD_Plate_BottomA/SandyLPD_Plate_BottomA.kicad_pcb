# Repository jpskenn/SandyLP-Duo

File README.md:

# SandyLP Duo（サンディ エルピー デュオ）

"SandyLP Duo" is a Split 40% keyboard with symmetrical row staggered layout and key height optimization.

Layered PCB will make height differences for each key.
This covers the lack of optimization to physical key layout in two dimensions that only adjust x-y plane.

---

SandyLP Duoは、スイッチの配置を立体的にして高さ方向への最適化を加えた、左右対称ロースタッガード配列の分割型40%キーボードです。  

平面上のキーレイアウトだけでは最適化しきれない部分を、キーの位置に応じてスイッチを配置する高さを変えることで補っています。

開発の元となった[SandyLP](https://github.com/jpskenn/SandyLP)の機能や特徴を踏襲しつつ、肩や腕を開いたより自然なポジションでの打鍵と、テンティングによる手首や腕の負荷軽減を目指しています。

SandyLPのコンセプトをそのまま引きついだバリエーションモデルとして、分割型の特徴である左右ふたつのペアを思わせる言葉の「Duo」を後ろにつけ、「SandyLP Duo」としました。  
元の元であるSandyから説明すると、スイッチを立体的（3D）に配置したキーボードの、ロープロファイル版、分割型バリエーションモデルということになります。

## 特徴

### 分割型

見てのとおり、右手用と左手用のふたつに分かれた、分割型キーボードです。
右手用または左手用のどちらかをPCやMacに接続し、もう一方へUSB Type-Cケーブルで接続します。

右手用と左手用を好みの場所に配置し、好みのポジションで打鍵できます。
前作の一体型キーボードSandyLP（中央部に2u分の間隔）に比べ、肩や腕を大きく開いたポジションをとることが可能で、肩や腕の負荷軽減が見込まれます。

また、ゴム足等を使ったテンティング（キーボードの内側を持ち上げて、親指側と小指側の高さを変える）をおこなうことで、手首や腕の負荷軽減が見込まれます。

### 左右対称のキーレイアウト  

[Jones](https://github.com/jpskenn/Jones)と同様の、2行目と3行目にずれのない、左右対称なシンメトリカル ロースタッガードのレイアウトです。  

一般的なロースタッガードなレイアウトとの共通性を残しつつ、左右対称で打鍵しやすくなるよう、[SemiErgo Layout](https://github.com/mtei/SemiErgo_Layout)に準ずるキーマッピングで使用することを念頭に設計しています。  
Z行の左右端にシフトキーを用意していないので、スペースキーを「Space and Shift」として使うと便利です。

このレイアウトは、市販の各種キーキャップセットのうち「Base Kit」と呼ばれる基本的なキットですべてを埋めることができます。また、104キーの英語キーキャップセットでも十分実用が可能です。
〓Base Kitと104の検証

詳しくは、[Keyboard Layout Editor: SandyLP Duo]()を参照してください。

### キースイッチを立体的に配置  

前機種の[Sandy](https://github.com/jpskenn/Sandy)と同じく、キースイッチを3段階の高さで立体的に配置しています。  
平面上ではキーを配置できる範囲が限られるため、一部のキーはどうしても指が届きにくくなってしまいます。例えば、[Jones](https://github.com/jpskenn/Jones)では左右対称のレイアウトを採用することで右手小指の`P`や`Back Space`、`Enter`などは打鍵しやすくなりましたが、右手人差し指の`Y`は少し遠く感じられました。  
このような箇所について、キーの配置を高くすることで打鍵しやすさを向上させています。  

キーの高さはLow（基準高＝0mm）, Middle（3.6mm）, High（8.7mm）の3段階で、以下のように配置されます。  

### キーボード自体が低い（薄い）  

ロープロファイルの`Choc V2`スイッチを採用することでキーボード自体が低くなりました。  
前機種のSandyからは7.2mm（※1）低くなり、パームレストを使わずとも、手首をあまり反らさないポジションで打鍵できます。

※1 ボトムプレートから1段目のスイッチ軸の天面までの高さを比較。なお、Sandyは理論上あと0.8mm低くすることが可能です。

### RP2040を採用した構成により、多機能なファームウェアを使用可能

RP2040を採用した構成により、キーボード向けのファームウェアを格納するには十分すぎるほどのフラッシュ容量を得ることができました。  
エンコーダーやオーディオ、その他各種機能の同時有効化や、多数のレイヤーを使用するなど、多機能なファームウェアを使用可能です。

### Remap、Vialによるキー割り当ての変更  

初期書き込み済みのファームウェアは[Remap](https://remap-keys.app/)に対応しており、プログラミング等の知識がなくても、キーマッピングやロータリーエンコーダへの割り当てを、ブラウザ等を使って簡単に変更できます。  

また、Vial対応のファームウェアに書き換えて使用することもできます。

### オプション機能  

- ロータリーエンコーダ
- インジケータLED
- オーディオ

## ビルドガイド

## SNSタグ

[#SandyLP_Duo](https://twitter.com/search?q=%23SandyLP_Duo)

## ギャラリー

## 参考事例

## 開発経緯

## KiCad design PCB/SandyLPD_Base/SandyLPD_Base.kicad_pcb

Parts:
C1, C2, C17, C18: 10u; C_0805_2012Metric; LCSC C15850
C3, C4, C5, C6, C7, C8, C9, C10, C11, C12, C19, C20, C21, C24, C28, C29, C30, C31, C32, C33: 100n; C_0402_1005Metric; LCSC C1525
C13, C14, C15, C34, C35, C36: 2.2uF; C_0402_1005Metric; LCSC C307418
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D45: D; D_SOD-123_Emphasized_Direction_Line_Reference_on_bottom; LCSC C81598
D96, D97, D98, D99: PRTR5V0U2X; SOT-143; LCSC C78442
F1, F2, F3, F4: Fuse; Fuse_1206_3216Metric; LCSC C3020147
H_btm_1, H_btm_2, H_btm_3, H_btm_4, H_btm_5, H_btm_6: MountingHole; MountingHole_M2_Through-hole_tap_THC-0.8-1.0-2_minimal
H_mid_1, H_mid_2, H_mid_3, H_mid_4, H_mid_5, H_mid_6, H_mid_7, H_mid_8, H_mid_9, H_mid_10, H_mid_11, H_mid_12, H_mid_13, H_mid_14, H_mid_15, H_mid_16, H_mid_17, H_mid_18, H_mid_19, H_mid_20, H_mid_21, H_mid_22: MountingHole; MountingHole_M2_Through-hole_tap_THC-0.8-2.0-2_minimal
J1, J9: Conn_02x02_Odd_Even; PinHeader_2x02_P2.00mm_Vertical_2pair
J2, J11: Conn_01x03; PinHeader_1x03_P2.54mm_Vertical_All_circle
J4, J10: Conn_01x10_Pin; PinHeader_1x10_P1.00mm_Vertical
J5, J6, J7, J8: USB_C_Receptacle_USB2.0; USB_C_Receptacle_HRO_TYPE-C-31-M-12; LCSC C165948
JP1, JP3: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm_no_Courtyard
L1, L2, L3, L4, L5, L6: WS2812B-2020; LED_WS2812B-2020_PLCC4_2.0x2.0mm_with_3D_model
LS1, LS2: Speaker; Buzzer_Murata_PKMCS0909E; LCSC-Reserve C910763
Q1, Q3: AO3401A; SOT-23
Q2, Q4: DMMT5401; SC-74-6_1.55x2.9mm_P0.95mm
R1, R5, R6, R7, R9, R14, R21, R22: 1k; R_0402_1005Metric; LCSC C11702
R2, R3, R17, R18: 27; R_0402_1005Metric; LCSC C25100
R4, R8, R19, R20, R23, R24, R25, R26: 10k; R_0402_1005Metric; LCSC C25744
R10, R11, R13, R15: 5.1k; R_0402_1005Metric; LCSC C25905
R12, R16: 5.6k; R_0402_1005Metric; LCSC C25905
STLED1, STLED2: LED_GREEN; LED_0805_2012Metric; LCSC C2297
SW1, SW4: BOOT_ALT; SW_SPST_PTS810; LCSC-Reserve C116501
SW2, SW5: RESET_ALT; SW_SPST_PTS810; LCSC-Reserve C116501
SW3, SW6: SW_DIP_x04; SW_DIP_SPSTx04_Slide_Copal_CHS-04B_W7.62mm_P1.27mm
SW_1: W; Kailh_socket_ChocV2
SW_2: E; Kailh_socket_ChocV2
SW_3: LCTL; Kailh_socket_ChocV2
SW_4: A; Kailh_socket_ChocV2
SW_5: S; Kailh_socket_ChocV2
SW_6: D; Kailh_socket_ChocV2
SW_7: F; Kailh_socket_ChocV2
SW_8: Z; Kailh_socket_ChocV2
SW_9: X; Kailh_socket_ChocV2
SW_10: C; Kailh_socket_ChocV2
SW_11: V; Kailh_socket_ChocV2
SW_12: B; Kailh_socket_ChocV2
SW_13: L_RE; ChocV2_AND_RotaryEncoder_Alps_EC11E-Switch_Vertical_H20mm_N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
SW_14: LALT; Kailh_socket_ChocV2
SW_15: LSPC; Kailh_socket_ChocV2
SW_16: L_CNT; Kailh_socket_ChocV2
SW_17: I; Kailh_socket_ChocV2
SW_18: O; Kailh_socket_ChocV2
SW_19: J; Kailh_socket_ChocV2
SW_20: K; Kailh_socket_ChocV2
SW_21: L; Kailh_socket_ChocV2
SW_22: -; Kailh_socket_ChocV2
SW_23: ENT; Kailh_socket_ChocV2
SW_24: N; Kailh_socket_ChocV2
SW_25: M; Kailh_socket_ChocV2
SW_26: <,; Kailh_socket_ChocV2
SW_27: >.; Kailh_socket_ChocV2
SW_28: ?/; Kailh_socket_ChocV2
SW_29: R_RE; ChocV2_AND_RotaryEncoder_Alps_EC11E-Switch_Vertical_H20mm_N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
SW_30: R_CNT; Kailh_socket_ChocV2
SW_31: RSPC; Kailh_socket_ChocV2
SW_32: RALT; Kailh_socket_ChocV2
SW_33: RWIN; Kailh_socket_ChocV2
SW_LWIN1: LWIN; Kailh_socket_ChocV2
T_L_C0, T_L_C1, T_L_C2, T_L_C3, T_L_C4, T_L_C5: Conn_01x01; TestPoint_THTPad_D2.0mm_Drill1.0mm
T_L_R0, T_L_R1, T_L_R2, T_L_R3: Conn_01x01; TestPoint_THTPad_D2.0mm_Drill1.0mm
T_R_C0, T_R_C1, T_R_C2, T_R_C3, T_R_C4, T_R_C5: Conn_01x01; TestPoint_THTPad_D2.0mm_Drill1.0mm
T_R_R0, T_R_R1, T_R_R2, T_R_R3: Conn_01x01; TestPoint_THTPad_D2.0mm_Drill1.0mm
U1, U2: NCP1117-3.3_SOT223; SOT-223-3_TabPin2; LCSC C347222
U3, U5: RP2040; RP2040-QFN-56; LCSC C2040
U4, U6: W25Q128JVPIQ; WSON-8-1EP_6x5mm_P1.27mm_EP3.4x4.3mm; LCSC C190862
Y1, Y2: 12MHz; Resonator_SMD_Murata_CSTxExxV-3Pin_3.0x1.1mm; MFR.Part # CSTNE12M0G550000R0; LCSC C341520

Connections:
+1V1: C3.1, C4.1, C14.1, U3.23 (DVDD), U3.45 (VREG_VOUT), U3.50 (DVDD)
+1V1_R: C19.1, C20.1, C35.1, U5.23 (DVDD), U5.45 (VREG_VOUT), U5.50 (DVDD)
+3V3: C2.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C15.1, R1.2, R4.1, U1.2 (VO), U3.1 (IOVDD), U3.10 (IOVDD), U3.22 (IOVDD), U3.33 (IOVDD), U3.42 (IOVDD), U3.43 (ADC_AVDD), U3.44 (VREG_IN), U3.48 (USB_VDD), U3.49 (IOVDD), U4.8 (VCC)
+3V3_R: C18.1, C21.1, C24.1, C28.1, C29.1, C30.1, C31.1, C32.1, C33.1, C34.1, C36.1, R7.2, R20.1, U2.2 (VO), U5.1 (IOVDD), U5.10 (IOVDD), U5.22 (IOVDD), U5.33 (IOVDD), U5.42 (IOVDD), U5.43 (ADC_AVDD), U5.44 (VREG_IN), U5.48 (USB_VDD), U5.49 (IOVDD), U6.8 (VCC)
L_Audio: D35.1 (K), R9.2, U3.30 (GPIO19)
L_D+: D98.2 (I/O1), J5.A6 (D+), J5.B6 (D+), R2.2
L_D-: D98.3 (I/O2), J5.A7 (D-), J5.B7 (D-), R3.2
L_LED: L1.3 (DIN), U3.32 (GPIO21)
L_QSPI_SCLK: U3.52 (QSPI_SCLK), U4.6 (CLK)
L_QSPI_SD0: U3.53 (QSPI_SD0), U4.5 (DI(IO0))
L_QSPI_SD1: U3.55 (QSPI_SD1), U4.2 (DO(IO1))
L_QSPI_SD2: U3.54 (QSPI_SD2), U4.3 (IO2)
L_QSPI_SD3: U3.51 (QSPI_SD3), U4.7 (IO3)
L_QSPI_SS: R4.2, R5.2, U3.56 (QSPI_SS), U4.1 (~CS)
L_RESERVE1: J4.1, U3.5 (GPIO3)
L_RESERVE2: J4.2, U3.6 (GPIO4)
L_RESERVE3: J4.3, U3.7 (GPIO5)
L_RESERVE4: J4.4, U3.8 (GPIO6)
L_RESERVE5: J4.5, U3.9 (GPIO7)
L_RESERVE6: J4.6, U3.11 (GPIO8)
L_RESERVE7: J4.7, U3.12 (GPIO9)
L_RESERVE8: J4.8, U3.13 (GPIO10)
L_RESERVE9: J4.9, U3.14 (GPIO11)
L_RESERVE10: J4.10, U3.15 (GPIO12)
L_RE_A: SW_13.A, U3.28 (GPIO17)
L_RE_B: SW_13.B, U3.29 (GPIO18)
L_RX: D96.3 (I/O2), J6.A7 (D-), J6.B7 (D-), U3.3 (GPIO1)
L_SWCLK: J2.1, U3.24 (SWCLK)
L_SWD: J2.3, U3.25 (SWD)
L_TX: D96.2 (I/O1), J6.A6 (D+), J6.B6 (D+), U3.2 (GPIO0)
L_VBUS_detection: R8.1, R12.1, U3.41 (GPIO29_ADC3)
L_col2: SW_1.1, SW_5.1, SW_10.1, SW_LWIN1.1, T_L_C2.1, U3.37 (GPIO25)
L_col3: SW_2.1, SW_6.1, SW_11.1, SW_14.1, T_L_C3.1, U3.38 (GPIO26_ADC0)
L_dip1: SW3.4, U3.18 (GPIO15)
L_dip2: SW3.3, U3.17 (GPIO14)
L_dip3: SW3.2, U3.16 (GPIO13)
L_row3: D13.1 (K), D14.1 (K), D15.1 (K), D16.1 (K), D17.1 (K), T_L_R3.1, U3.27 (GPIO16)
unnamed: D1.2 (A), SW_1.2
unnamed: D2.2 (A), SW_2.2
unnamed: D3.2 (A), SW_3.2
unnamed: D4.2 (A), SW_4.2
unnamed: D5.2 (A), SW_5.2
unnamed: D6.2 (A), SW_6.2
unnamed: D7.2 (A), SW_7.2
unnamed: D8.2 (A), SW_8.2
unnamed: D9.2 (A), SW_9.2
unnamed: D10.2 (A), SW_10.2
unnamed: D11.2 (A), SW_11.2
unnamed: D12.2 (A), SW_12.2
unnamed: D13.2 (A), SW_LWIN1.2
unnamed: D14.2 (A), SW_14.2
unnamed: D15.2 (A), SW_15.2
unnamed: D16.2 (A), SW_16.2
unnamed: D17.2 (A), SW_13.S2
unnamed: D18.2 (A), SW_17.2
unnamed: D19.2 (A), SW_18.2
unnamed: D20.2 (A), SW_19.2
unnamed: D21.2 (A), SW_20.2
unnamed: D22.2 (A), SW_21.2
unnamed: D23.2 (A), SW_22.2
unnamed: D24.2 (A), SW_23.2
unnamed: D25.2 (A), SW_24.2
unnamed: D26.2 (A), SW_25.2
unnamed: D27.2 (A), SW_26.2
unnamed: D28.2 (A), SW_27.2
unnamed: D29.2 (A), SW_28.2
unnamed: D30.2 (A), SW_30.2
unnamed: D31.2 (A), SW_31.2
unnamed: D32.2 (A), SW_32.2
unnamed: D33.2 (A), SW_33.2
unnamed: D34.2 (A), SW_29.S2
unnamed: F3.1, J6.A4 (VBUS), J6.A9 (VBUS), J6.B4 (VBUS), J6.B9 (VBUS)
unnamed: F4.1, J7.A4 (VBUS), J7.A9 (VBUS), J7.B4 (VBUS), J7.B9 (VBUS)
unnamed: J5.A5 (CC1), R10.1
unnamed: J5.B5 (CC2), R11.1
unnamed: J8.A5 (CC1), R13.1
unnamed: J8.B5 (CC2), R15.1
unnamed: L1.1 (DOUT), L2.3 (DIN)
unnamed: L2.1 (DOUT), L3.3 (DIN)
unnamed: L4.1 (DOUT), L5.3 (DIN)
unnamed: L5.1 (DOUT), L6.3 (DIN)
unnamed: LS1.1, R9.1
unnamed: LS2.1, R14.1
unnamed: F1.2, Q1.3 (D), Q2.5 (E2), R12.2
unnamed: Q1.1 (G), Q2.1 (C1), R24.1
unnamed: Q2.2 (B1), Q2.3 (B2), Q2.4 (C2), R23.1
unnamed: F2.2, Q3.3 (D), Q4.5 (E2), R16.2
unnamed: Q3.1 (G), Q4.1 (C1), R26.1
unnamed: Q4.2 (B1), Q4.3 (B2), Q4.4 (C2), R25.1
unnamed: R6.1, Y1.3
unnamed: R22.1, Y2.3
unnamed: R1.1, STLED1.2 (A)
unnamed: R7.1, STLED2.2 (A)
unnamed: R3.1, U3.46 (USB_DM)
unnamed: R2.1, U3.47 (USB_DP)
unnamed: U3.20 (XIN), Y1.1
unnamed: R6.2, U3.21 (XOUT)
unnamed: R18.1, U5.46 (USB_DM)
unnamed: R17.1, U5.47 (USB_DP)
unnamed: U5.20 (XIN), Y2.1
unnamed: R22.2, U5.21 (XOUT)
PowerLED_L: JP1.1 (A), STLED1.1 (K), SW3.1
PowerLED_R: JP3.2 (B), STLED2.1 (K), SW6.1
R_Audio: D45.1 (K), R14.2, U5.30 (GPIO19)
R_D+: D99.2 (I/O1), J8.A6 (D+), J8.B6 (D+), R17.2
R_D-: D99.3 (I/O2), J8.A7 (D-), J8.B7 (D-), R18.2
R_LED: L4.3 (DIN), U5.32 (GPIO21)
R_QSPI_SCLK: U5.52 (QSPI_SCLK), U6.6 (CLK)
R_QSPI_SD0: U5.53 (QSPI_SD0), U6.5 (DI(IO0))
R_QSPI_SD1: U5.55 (QSPI_SD1), U6.2 (DO(IO1))
R_QSPI_SD2: U5.54 (QSPI_SD2), U6.3 (IO2)
R_QSPI_SD3: U5.51 (QSPI_SD3), U6.7 (IO3)
R_QSPI_SS: R20.2, R21.2, U5.56 (QSPI_SS), U6.1 (~CS)
R_RESERVE1: J10.2, U5.28 (GPIO17)
R_RESERVE2: J10.3, U5.29 (GPIO18)
R_RESERVE3: J10.4, U5.31 (GPIO20)
R_RESERVE4: J10.5, U5.34 (GPIO22)
R_RESERVE5: J10.6, U5.35 (GPIO23)
R_RESERVE6: J10.7, U5.36 (GPIO24)
R_RESERVE7: J10.8, U5.37 (GPIO25)
R_RESERVE8: J10.9, U5.38 (GPIO26_ADC0)
R_RESERVE9: J10.10, U5.39 (GPIO27_ADC1)
R_RESERVE10: J10.1, U5.15 (GPIO12)
R_RE_A: SW_29.A, U5.13 (GPIO10)
R_RE_B: SW_29.B, U5.14 (GPIO11)
R_RX: D97.2 (I/O1), J7.A6 (D+), J7.B6 (D+), U5.3 (GPIO1)
R_SWCLK: J11.1, U5.24 (SWCLK)
R_SWD: J11.3, U5.25 (SWD)
R_TX: D97.3 (I/O2), J7.A7 (D-), J7.B7 (D-), U5.2 (GPIO0)
R_VBUS_detection: R16.1, R19.1, U5.41 (GPIO29_ADC3)
R_col2: SW_18.1, SW_21.1, SW_26.1, SW_33.1, T_R_C2.1, U5.12 (GPIO9)
R_col3: SW_17.1, SW_20.1, SW_25.1, SW_32.1, T_R_C3.1, U5.11 (GPIO8)
R_dip1: SW6.4, U5.18 (GPIO15)
R_dip2: SW6.3, U5.17 (GPIO14)
R_dip3: SW6.2, U5.16 (GPIO13)
R_row3: D30.1 (K), D31.1 (K), D32.1 (K), D33.1 (K), D34.1 (K), T_R_R3.1, U5.4 (GPIO2)
VBUS: D98.4 (VCC), F1.1, J5.A4 (VBUS), J5.A9 (VBUS), J5.B4 (VBUS), J5.B9 (VBUS)
VBUS_R: D99.4 (VCC), F2.1, J8.A4 (VBUS), J8.A9 (VBUS), J8.B4 (VBUS), J8.B9 (VBUS)

Notes on the sheet:
No Switch at Row3, Col0
Mid
ピンはとりあえず仮に配置してるだけ。 MCUを基板に配置後、最適化する予定。
Mid-ISO
TODO RP2040まわりの右手側 仮想接続 ネジ
Top
R>L Connection
Base to Top via Mid Left
WS2812C バイパスコンデンサ不要
SCREWS to Mid
L>R Connection
SCREWS to Bottom Plate
Speaker
USB
Base to Top via Mid Right
Connection diagram (Virtual)
Base to Mid-ISO Right
44PIN
45PIN
Base to Mid Right
Reserved pins
Base to Mid-ISO Left
LED
ERCチェックで、 TopとMidのラベルが見つからないのはOK。 （別プロジェクトでやる）
KEY MATRIX, Base plate
Base to Mid Left
DIP Switch
Max keys = 10 rows * 8 cols = 80 Physical keys = 15 + 14 + 14 + 15 + 13 = 71 5-way nav = 5 Remap/VIA virtual key assign for 2 encoders = 2 * 2 = 4 Balance = 0 (!)

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
Board: 2 copper layers, 271.5 x 101.0 mm, 222 parts (160 on the bottom side), 160 nets.

## KiCad design PCB/SandyLPD_Mid-ISO/SandyLPD_Mid-ISO.kicad_pcb

Board: 2 copper layers, 42.5 x 23.2 mm, 18 parts (7 on the bottom side), 7 nets.

Parts:
Cutout1: 60_Outline; SandyLPD_outline_Mid-ISO
D1, D2, D3, D4: D; D_SOD-123_Emphasized_Direction_Line
H1, H2, H3, H4: MountingHole; MountingHole_2.2-4.8mm_M2_Pad_minimal_for_Through-hole_tap_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
H5, H6: MountingHole; MountingHole_M2_Through-hole_tap_THC-0.8-1.0-2
SW_BS1: SW_Push; Kailh_socket_ChocV2_for_Reverse_no_hole
SW_P1: SW_Push; Kailh_socket_ChocV2_small_#2pad_for_Reverse_no_hole
SW_Q1: SW_Push; Kailh_socket_ChocV2_for_Reverse
SW_TAB1: SW_Push; Kailh_socket_ChocV2_for_Reverse_narrow_#1_and_#2pad
T_C0, T_C1: Conn_01x01; TestPoint_THTPad_D2.0mm_Drill1.0mm
T_R1: Conn_01x01; TestPoint_THTPad_D2.0mm_Drill1.0mm

Connections:
LR_Mid-ISO_col0: H2.1, SW_P1.1, SW_TAB1.1, T_C0.1
LR_Mid-ISO_col1: H3.1, SW_BS1.1, SW_Q1.1, T_C1.1
LR_Mid-ISO_row0: D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), H1.1, T_R1.1
unnamed: D1.2 (A), SW_TAB1.2
unnamed: D2.2 (A), SW_Q1.2
unnamed: D3.2 (A), SW_P1.2
unnamed: D4.2 (A), SW_BS1.2

## KiCad design PCB/SandyLPD_Mid-CNT/SandyLPD_Mid-CNT.kicad_pcb

Parts:
D1, D2, D3, D4, D5, D6: D; D_SOD-123_Emphasized_Direction_Line; LCSC C81598
H1, H2, H3, H4: MountingHole; MountingHole_2.2-4.8mm_M2_Pad_minimal_for_Through-hole_tap_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
H5: MountingHole; MountingHole_M2_Through-hole_tap_THC-0.8-1.0-2
H_top_1, H_top_2, H_top_3: MountingHole; MountingHole_2.2-4.8mm_M2_Pad_minimal_for_Through-hole_tap
SW_G1: SW_Push; Kailh_socket_ChocV2_small_#2pad_for_Reverse_no_hole
SW_H1: SW_Push; Kailh_socket_ChocV2_for_Reverse
SW_MACRO_L1: SW_Push; Kailh_socket_ChocV2_small_#2pad_for_Reverse_no_hole
SW_MACRO_R1: SW_Push; Kailh_socket_ChocV2_for_Reverse
SW_R1: SW_Push; Kailh_socket_ChocV2_small_#2pad_for_Reverse_no_hole
SW_U1: SW_Push; Kailh_socket_ChocV2_for_Reverse
T_C4, T_C5: Conn_01x01; TestPoint_THTPad_D2.0mm_Drill1.0mm
T_R0, T_R1, T_R2: Conn_01x01; TestPoint_THTPad_D2.0mm_Drill1.0mm

Connections:
GND: H4.1, H_top_2.1
Mid_col4: H1.1, SW_R1.1, SW_U1.1, T_C4.1
Mid_col5: H_top_3.1, SW_G1.1, SW_H1.1, SW_MACRO_L1.1, SW_MACRO_R1.1, T_C5.1
Mid_row0: D1.1 (K), D4.1 (K), H_top_1.1, T_R0.1
Mid_row1: D2.1 (K), D5.1 (K), H2.1, T_R1.1
Mid_row2: D3.1 (K), D6.1 (K), H3.1, T_R2.1
unnamed: D1.2 (A), SW_R1.2
unnamed: D2.2 (A), SW_G1.2
unnamed: D3.2 (A), SW_MACRO_L1.2
unnamed: D4.2 (A), SW_U1.2
unnamed: D5.2 (A), SW_H1.2
unnamed: D6.2 (A), SW_MACRO_R1.2

Notes on the sheet:
Base & Top
以下の Panel CONNECTOR は、Baseからコピペ。 ERCの警告「別パネルのラベルがどこにも接続されていない」は、無視してOK。 ！！！他の警告（ラベルかぶりとか）は、しっかりチェックせよ！！！
SCREWS to Plate
SCREWS to Base
SCREWS to Base & Top
KEY MATRIX
